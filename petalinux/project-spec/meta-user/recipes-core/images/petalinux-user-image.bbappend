IMAGE_INSTALL += "packagegroup-core-buildessential"
